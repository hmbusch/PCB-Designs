# Repository hmbusch/PCB-Designs

File README:

======================================================================
= PCB-Designs                                                        =
= URL: https://github.com/hmbusch/PCB-Designs                        =
======================================================================

From time to time I sit down and design some circuitry that can be
used for multiple purposes, a component if you will. The designs for
these PCBs are stored in this project (or at least those I feel 
confident to share).

Contents
========

ChainableScrew595
-----------------

This design features a small PCB with an 74HC595 shift register
at it's heart. Multiple modules of these can be connected together
to form a shift register cascade. The register connects to an
ULN2803A Darlington Array sink driver whose outputs are available
as a 9 port screw header (8 ports + VCC connector).
As should be obvious from the design, this module can only be used
for sink switching, as it requires fewer and more common parts than
a similar design for source switching.

EAGLE-Libraries
---------------

Contains libraries for use with Cadsoft Eagle. These libraries 
contain parts and packages I added myself for components that 
are not contained in the stock libraries.

Pixel
-----

The Pixel is a small board that puts three 5mm LEDs in series with a
SMD resistor to create a larger light source than a single LED. The Pixel 
is supposed to be powered by 12 Volts and outfitted with three high 
brightness LEDs. The pixel is a good alternative to power LEDs in
terms of price, power consumption and temperature management.

## KiCad design wemos-d1-mini-mainboard/wemos-d1-mini-mainboard.kicad_pcb

Parts:
BT1: 18650 LiPo; BatteryHolder_Keystone_1042_1x18650_different_silkscreen
D1, D2: LED; LED_SMD_3528_1411
D3: Power LED; LED_SMD_3528_1411
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_I2C; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J2: Conn_D0; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J3: Conn_D7; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J4: Conn_D8; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J5: Conn_A0; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J6: Conn_D4; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J7: Conn_D3; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J8: Conn_D5; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J9: Conn_D6; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
R1, R2, R3: 120; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW4: SW_LOAD; SK22D07_DPDT_slide_switch
U1: WeMos_D1_mini; WEMOS_D1_mini_light
U2: TP4056-Module
VR1: Pololu S7V8x; Pololu S7V8x Voltage Regulator

Connections:
+3.3V: J1.4, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, R3.1, U1.8 (3V3), VR1.4 (VOUT)
/A0: J5.2, U1.2 (A0)
/BAT+: BT1.1 (+), U2.5 (Battery_+)
/BAT-: BT1.2 (-), U2.6 (Battery_-)
/D0: J2.2, U1.3 (D0)
/D3: J7.2, U1.12 (D3)
/D4: J6.2, U1.11 (D4)
/D5: J8.2, R1.1, U1.4 (SCK/D5)
/D6: J9.2, R2.1, U1.5 (MISO/D6)
/D7: J3.2, U1.6 (MOSI/D7)
/D8: J4.2, U1.7 (CS/D8)
/OUT+: SW4.1 (A), U2.3 (OUT_+)
/OUT-: SW4.4 (A), U2.4 (OUT_-)
/SCL: J1.3, U1.14 (SCL/D1)
/SDA: J1.2, U1.13 (SDA/D2)
/V_LIPO: SW4.2 (B), VR1.2 (VIN)
GND: D1.1 (K), D2.1 (K), D3.1 (K), J1.1, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.3, SW4.5 (B), U1.10 (GND), VR1.3 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2

Board: 2 copper layers, 94.0 x 68.0 mm, 24 parts (0 on the bottom side), 20 nets.

## Commit log (part)

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2011-08-17 First checkin of completed design
2011-08-17 Added some basic READMEs
2012-01-03 Updated the README with info on the EAGLE library
2012-01-03 Added 2N7002 SMD MOSFET and 1/4W resistor with axial and SMD package. Cleaned up some of the other components with regard to labels, layers, etc.
2012-01-11 Added a very small PCB that carries 3 5mm LEDs to create a larger "pixel" from common high brightness LEDs instead of Power LEDs.
2012-01-11 Rearranged files for better overview.
2012-01-11 Added 3mm, 5mm and 10mm LEDs
2012-01-11 Updated the README for the Pixel
2012-02-23 Added SMD footprints for the HopeRF RFM01 and RFM02 modules. RFM01 is the ISM band FSK receiver, RFM02 is the ISM band FSK transmitter. Both modules are sold in Germany by Pollin.
2012-02-25 Added >NAME and >VALUE labels to the seven segment packages and symbols. Also added a drill hole for the potentiometer.
2012-03-08 Moved the seven-segment package pins onto a 0.1 inch grid for better signal routing. The MOSFET pin descriptions were switched onto another layer to make them appear by default in the schematics.
2012-03-08 Renamed the supply parts in some components to something useful.
2012-03-15 Added the DIP-18 package and created the symbol and device for the ULN2803 Darlington Array
2012-03-15 - Added the 74*595 shift register with two packages - Active low pins on ICs are now designated as such - Enabled user value on the resistor device - Added devices for 5-pin and 8-pin headers
2012-03-20 After the first (desastrously failed) attempt to layout the seven segment PCB, the second approach looks more promising so far.
2012-03-20 Added the backups of the PCB layout to the ignored files.
2012-03-20 Hmm, this was supposed to be the commit regarding the second try on layouting the PCB. So, here it goes: the is the first step of the second try of layouting the PCB and it looks more promising so fa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
2012-03-21 Assigned a proper name to a few more signals to make the layouting process easier (proper names enable precise filtering with the RATSNEST command)
2012-03-21 Started all over again, this time with a 2-layer PCB intended for professional manufacturing. Trying to squeeze SMD components and 'wire-intensive' parts like seven-segment displays on a single-sided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
2012-03-21 Fixed stupid bug in the circuit design: The digit anodes were all switched per seven-segment part, i.e. digit 1 was connected to the decade counter line 2 and digit 2 to decade counter line 1, and so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
2012-03-21 Finished the 2-layer PCB layout. Now all thats missing is a ground plane and some labeling.
2012-03-25 Duplicated some of the labels onto the bottom silkscreen layer. Especially the pin labeling is useful.
2012-04-07 Added PLCC6 package and RGB LED using this package
2012-04-09 Increased drill size on headers from .8mm to 1mm
    The drill size on the breakaway header packages was too small to actually
    fit any such header. D'oh! Increased the drill size to 1mm and adjusted
    the silkscreen markings accordingly.
2012-04-09 Created gerber files for project
    The design was translated to gerber files using the CAM job configuration
    from Seeed Studio for their Fusion PCB service. The job generated a lot
    more files, but Fusion PCB only needs those added now.
2012-04-09 New (correct) 8-pin connector and level fix for some labels.
    Replaced the 8-pin connector with the fixed version from the library (w/
    larger pads and 1mm drill size instead of .8mm). Had to rearrange some
    wires and labels. The bottom labels were accidentally placed on bPlace
    instead of bNames, this is now also fixed.
2012-04-09 Created a new library just for connectors.
    Since the content of a single library tends to get a little chaotic, I
    have decided t split the library by component group. This first new
    library contains all connectors specified so far. These have been moved
    from the general library to the new one.
2012-04-19 Added new packages for locking pin connectors, renamed the 90� packages.
    Specifications for locking headers taken from W�rth Elektronik datasheet
    for the WR-WTB 2.54mm header series
    (http://katalog.we-online.de/kataloge/eican/index.php?language=en&pf=619_0xx_110_21).
2012-04-20 Added a small selection of WIMA MKS-2 film capacitors.
2012-04-23 Fixed serious bug: the register's CLEAR pin is now pulled high instead of low.
    The CLEAR pin of the 74HC595 was accidentally connected to ground,
    pulling it low and thereby active all the time, preventing the register
    from working normally. It is now pulled to high and thereby inactive,
    allowing normal operation.
    The board now bears the version 1.1. The board has been updated to use the
    parts from the new sub-libraries. The last throughole resister has been
2012-05-06 Moved all LED components (inlcuding seven-segment) to a dedicated library file.
2012-05-06 Started work on a library for voltage regulators.
    So far not much to see except for the TO-220 package.
2012-05-16 Created a new library for integrated circuits and moved all IC devices and packages from the old main library to this new one
2012-05-17 Added MAX7219 IC, also added DIP-24 package, DIP-28 was created by mistake
2012-05-18 Added screw type terminal blocks with various pin counts
2012-05-18 Added electrolytic capacitor modelled after Yageo's S5 series, 35V, 10uF, 5x5mm can size
2012-05-19 Adjusted some small inconsistencies
2012-05-19 Created a breakout board for the MAX7219 chip.
    This board features a MAX7219 chip, stabilizing capacitors as suggested by
    the datasheet, voltage divider resistors for setting the maximum segment
    current and 4 reordered connectors, one for digits, one for segment, one
    control input and one control output to daisy chain multiple breaktout
    boards. The digit and segment connectors offer footprints for pin headers
    and screw type block terminals.
2012-05-22 Optimized the 2N7000 MOSFET component by rearranging some label, making the value user definable and adding a common prefix.
2012-05-22 Removed silkscreen overlap on SMD resistor
2012-05-26 Added pin headers with one and seven pins (mainly for breakouts)
2012-05-26 Added the WS2801 RGB controller IC and its SO-14 package
2012-05-26 Removed several stopmask/label overlaps
2012-06-03 Added two small SMD breakout board, one for SOP-14 SMD ICs, the other one for G3528 / PLCC2 SMD LEDs
2012-06-08 Added the SN75176B/MAX485 IC and associated DIP-8 package
2012-06-08 Added a USB Type B receptacle (USB 1.0/2.0 only)
2012-06-08 Added FTDIs FT232R USB/UART IC and the impossible SSOP28 package
2014-11-09 Added the LM358 op-amp
    And EAGLE did some reformatting...
2014-11-12 Added the HopeRF RFM69HCW transceiver
2014-11-12 Created a breakout board for the HopeRF RFM69HCW
2016-07-01 Updated submodules
2016-07-11 Added the Adafruit HUZZAH ESP8266 Basic Breakout
2016-07-11 Added 1S LiPo BMS/charger module
    The small modules found on ebay featuring a Micro-USB
    port, A TP4056 charge controller and a DW01 cell
    protection IC.
2016-07-21 Added new 10x13mm (5mm pitch) package for polarized caps
2016-07-21 Removed some unneccessary wires
2016-08-14 Updated the Sparkfun repository
2023-08-22 Wemos D1 Mainboard v1.0 added
    See README.md for more details on this design.
2023-08-22 Wemos D1 Mainboard: Added JLCPCB production files
    I generated the production files for the Wemos D1 Mainboard for
    production by JLCPCB. I sent those exact files off for production.
2023-08-22 Added folder for KiCad 3D models
    I initially added a 3D model for the TP4056 module, but it was
    not created by me, so I omitted it due to copyright reasons. It
    can be downloaded from:
    https://kicadrookie.blogspot.com/2022/01/tp4056-module-kicad-3d-asset.html
    If you choose to download it, the scaling factor for all three
    axes when importing into KiCad seems to be 0.393.
2023-08-24 Wemos D1 Mainboard: changed LEDs to 1210 footprint
    1210 is a bit more versatile and is actually the LED component
    size I have in stock.
    The board had to be rerouted, so there a lot of actual file
    changes.
2023-09-02 Kicad: Added footprint for 3528 / 1411 PLCC2 LED
    Kicad seems only to contain either footprints that are a little to
    small for 3528/1411 or are asymmetrical, where one pad is almost
    double in size compared to the other. My SMD LEDs don't reflect that,
    so I added my own footprint based on a Kingbright SMD LED datasheet.
2023-09-02 Kicad: Fixed TP4056 battery pin spacing
    The initial spacing between `OUT+` and `BAT+` and the corresponding
    negative pads was 2.54mm. This however, does not line up with any
    actual TP4056 module I own (Micro-USB and USB-C versions), the pins
    are spaced further apart. I updated the footprint to reflect that.
2023-09-02 Wemos D1 Mainboard: Generated JLCPCB production files for v1.2
2023-09-25 Added two seven-segment symbols
    - Kingbright DC52-11GWA (common cathode)
    - Oasistek TOD-4201FG-2 (common anode)
2023-09-25 Added several older dual seven segment displays (#8)
    * Added symbols/footprints for 4 older seven segment displays
    - Kingbright DA04/DC04 dual 10.2mm seven segment (common anode only)
    - Kingbright DC52/DA52 dual 13.2mm seven segment (common cathode only)
    - Oasistek TOD-4201FG-B dual 10.2mm seven segment (common anode)
    - RTF VQE 21 1.5x12.7mm seven segment (displays +1.8. when all segments
    are lit, and yes, this is the pre-1989 GDR part)
2023-09-28 VQE 21: Fixed silkscreen, added 2nd version with less silkscreen
    The components silkscreen extended over the edge of the carrier
    PCB in one of my projects and since KiCAD currently has no trimming
    feature, I created a version with less silkscreen.
    Normally I wouldn't bother, but with panelization, you'll get silkscreen
    spill from one board into the adjacent one.
2023-11-10 Added symbols for A2331 and MX612E components
    - A2331 is a current limiting load switch
    - MX612E is a controller IC for brushed DC motors
2023-11-10 Added symbols for A2331 and MX612E components (#10)
    - A2331 is a current limiting load switch
    - MX612E is a controller IC for brushed DC motors
2023-11-10 Reverse engineered schematic of a cheap watch winder PCB (#11)
    This is the schematic I reverse engineered from the control PCB
    of one of the cheap watch winders from Amazon/AliExpress where
    the PCB, DC socket and power switch form one combined part.
    There may be inaccuracies , especially regarding the microcontroller.
    The chosen PIC makes sense from a pinout and capabilities perspective,
    but it might be a different controller alltogether (markings had been
2024-04-21 Added Kicad 8 cache folder to .gitignore
2024-04-21 Added KiCads cache folder to ignore file (#12)
2024-10-21 Updated files to KiCad 8 (#13)
2024-10-21 Battery Discharger v1, initial commit
    Most battery dischargers are lacking the feature of approaching
    the low voltage threshold multiple times, each time reducing the
    discharge current, resulting in additional manual supervision
    needed or in batteries that are not accurately discharged.
    I will try to design my own (simple) discharger that incorporates
    this logic.
2024-10-21 Updated the README (#14)
2024-10-26 Added footprint for ALPS SKRK Series Push Button
    See https://tech.alpsalpine.com/e/products/category/tact-switch/sub/02/series/skrk/
    for more details regarding this component.
