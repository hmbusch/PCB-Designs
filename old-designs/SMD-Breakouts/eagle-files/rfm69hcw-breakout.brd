# Repository hmbusch/PCB-Designs

File README:

======================================================================
= PCB-Designs                                                        =
= URL: https://github.com/hmbusch/PCB-Designs                        =
======================================================================

From time to time I sit down and design some circuitry that can be
used for multiple purposes, a component if you will. The designs for
these PCBs are stored in this project (or at least those I feel 
confident to share).

Contents
========

ChainableScrew595
-----------------

This design features a small PCB with an 74HC595 shift register
at it's heart. Multiple modules of these can be connected together
to form a shift register cascade. The register connects to an
ULN2803A Darlington Array sink driver whose outputs are available
as a 9 port screw header (8 ports + VCC connector).
As should be obvious from the design, this module can only be used
for sink switching, as it requires fewer and more common parts than
a similar design for source switching.

EAGLE-Libraries
---------------

Contains libraries for use with Cadsoft Eagle. These libraries 
contain parts and packages I added myself for components that 
are not contained in the stock libraries.

Pixel
-----

The Pixel is a small board that puts three 5mm LEDs in series with a
SMD resistor to create a larger light source than a single LED. The Pixel 
is supposed to be powered by 12 Volts and outfitted with three high 
brightness LEDs. The pixel is a good alternative to power LEDs in
terms of price, power consumption and temperature management.

## EAGLE design old-designs/SMD-Breakouts/eagle-files/rfm69hcw-breakout.brd

Parts:
C1, C2: PIN_HEADER_8-WIDE; BREAKAWAY_STRAIGHT_8_WIDE
C3: 104; CERAMIC_CAP_5MM
C4: PIN_HEADER_1-WIDE; BREAKAWAY_STRAIGHT_1_WIDE
TRANSCEIVER: RFM69HCW-S2; HOPE-RF-16

Connections:
ANT: C2.8, C4.1, TRANSCEIVER.ANT
DIO0: C2.3, TRANSCEIVER.DIO0
DIO1: C2.2, TRANSCEIVER.DIO1
DIO2: C2.1, TRANSCEIVER.DIO2
DIO3: C2.6, TRANSCEIVER.DIO3
DIO4: C2.5, TRANSCEIVER.DIO4
DIO5: C1.7, TRANSCEIVER.DIO5
GND: C1.1, C1.8, C2.7, C3.P$2, TRANSCEIVER.GND1 (GND_1), TRANSCEIVER.GND2 (GND_2), TRANSCEIVER.GND3 (GND_3)
MISO: C1.2, TRANSCEIVER.MISO
MOSI: C1.3, TRANSCEIVER.MOSI
NSS: C1.5, TRANSCEIVER.NSS
RESET: C1.6, TRANSCEIVER.RESET
SCK: C1.4, TRANSCEIVER.SCK
VCC: C2.4, C3.P$1, TRANSCEIVER.3.3V (VCC)

Board: 2 copper layers, 26.0 x 29.2 mm, 5 parts (0 on the bottom side), 14 nets.

## EAGLE design SMD-Breakouts/eagle-files/so14-breakout.brd

Parts:
C1, C2: PIN_HEADER_7-WIDE; BREAKAWAY_STRAIGHT_7_WIDE
IC1: WS2801-SO14; SO-14

Connections:
GND: C1.7, IC1.7 (GND)
unnamed: C1.1, IC1.1 (CLOCK)
unnamed: C1.2, IC1.2 (DATA)
unnamed: C1.3, IC1.3 (POLARITY)
unnamed: C1.4, IC1.4 (RED_REF)
unnamed: C1.5, IC1.5 (GREEN_REF)
unnamed: C1.6, IC1.6 (BLUE_REF)
unnamed: C2.1, IC1.8 (BLUE_OUT)
unnamed: C2.2, IC1.9 (GREEN_OUT)
unnamed: C2.3, IC1.10 (RED_OUT)
unnamed: C2.5, IC1.12 (DATA_OUT)
unnamed: C2.6, IC1.13 (CLOCK_OUT)
unnamed: C2.7, IC1.14 (VCC)
unnamed: C2.4, IC1.11 (NC)

Notes on the sheet:
SO-14 SMB Breakout Board
https://github.com/hmbusch/PCB-Designs
Creative Commons BY-NC-SA 3.0 Germany License

Board: 2 copper layers, 20.3 x 20.3 mm, 3 parts (0 on the bottom side), 14 nets.

## EAGLE design Max7219Breakout/eagle-files/max7219_breakout.brd

Parts:
C1, C2: PIN_HEADER_8-SCREW-TERMINAL; TERMINAL_BLOCK_8
C3: CAPACITOR_POLARIZED-5X5-2.0; CAP_POL_5X5_2
C4: CAPACITOR-CERAMIC-5MM; CERAMIC_CAP_5MM
CON_IN: PIN_HEADER_5-WIDE; BREAKAWAY_STRAIGHT_5_WIDE
CON_OUT: PIN_HEADER_5-WIDE; BREAKAWAY_STRAIGHT_5_WIDE
DIG_CON: PIN_HEADER_8-WIDE; BREAKAWAY_STRAIGHT_8_WIDE
IC1: MAX7219CNG; DIP-24
R1, R2: RESISTOR-1/4W-12.7-AXIAL; RESISTOR-1/4W-AXIAL
SEG_CON: PIN_HEADER_8-WIDE; BREAKAWAY_STRAIGHT_8_WIDE

Connections:
+5V: C3.A, C4.P$2, CON_IN.1, CON_OUT.1, IC1.19 (VCC), R1.P$1 (1), R2.P$1 (1)
CLOCK: CON_IN.4, CON_OUT.4, IC1.13 (CLOCK)
DATA_IN: CON_IN.3, IC1.1 (DATA_IN)
DATA_OUT: CON_OUT.3, IC1.24 (DATA_OUT)
DIG_0: C1.P$1 (1), DIG_CON.1, IC1.2 (DIG_0)
DIG_1: C1.P$2 (2), DIG_CON.2, IC1.11 (DIG_1)
DIG_2: C1.P$3 (3), DIG_CON.3, IC1.6 (DIG_2)
DIG_3: C1.P$4 (4), DIG_CON.4, IC1.7 (DIG_3)
DIG_4: C1.P$5 (5), DIG_CON.5, IC1.3 (DIG_4)
DIG_5: C1.P$6 (6), DIG_CON.6, IC1.10 (DIG_5)
DIG_6: C1.P$7 (7), DIG_CON.7, IC1.5 (DIG_6)
DIG_7: C1.P$8 (8), DIG_CON.8, IC1.8 (DIG_7)
GND: C3.C, C4.P$1, CON_IN.2, CON_OUT.2, IC1.4 (GND_1), IC1.9 (GND_2)
LOAD: CON_IN.5, CON_OUT.5, IC1.12 (LOAD)
unnamed: IC1.18 (ISET), R1.P$2 (2), R2.P$2 (2)
SEG_A: C2.P$1 (1), IC1.14 (SEG_A), SEG_CON.1
SEG_B: C2.P$2 (2), IC1.16 (SEG_B), SEG_CON.2
SEG_C: C2.P$3 (3), IC1.20 (SEG_C), SEG_CON.3
SEG_D: C2.P$4 (4), IC1.23 (SEG_D), SEG_CON.4
SEG_DP: C2.P$8 (8), IC1.22 (SEG_DP), SEG_CON.8
SEG_E: C2.P$5 (5), IC1.21 (SEG_E), SEG_CON.5
SEG_F: C2.P$6 (6), IC1.15 (SEG_F), SEG_CON.6
SEG_G: C2.P$7 (7), IC1.17 (SEG_G), SEG_CON.7

Notes on the sheet:
Power Supply
Control in/out
Chip connections
MAX7219 Breakout Board
Hendrik Busch / https://githubs.com/hmbusch

Board: 2 copper layers, 53.3 x 57.1 mm, 11 parts (0 on the bottom side), 23 nets.

## EAGLE design SevenSegment/eagle-files/simple-8-digit-connector-board.brd

Parts:
7_SEG_1, 7_SEG_2, 7_SEG_3, 7_SEG_4: 7_SEGMENT-KB-DA04; KINGBRIGHT_DX04
C1: PIN_HEADER_8-ANGLED-WIDE; BREAKAWAY_ANGLED_8_WIDE
IC1: 74HC4017; SO-16
IC2: 74HC595; SO-16
IC3: ULN2803A; SO-18W
R1, R2, R3, R4, R5, R6, R7: 150; R1206
R8: 10K; R1206
T1, T2, T3, T4, T5, T6, T7, T8: 2N7002-SOT23; SOT23

Connections:
DA_IN_1: IC2.15 (QA), IC3.1 (IN_1)
DA_IN_2: IC2.1 (QB), IC3.2 (IN_2)
DA_IN_3: IC2.2 (QC), IC3.3 (IN_3)
DA_IN_4: IC2.3 (QD), IC3.4 (IN_4)
DA_IN_5: IC2.4 (QE), IC3.5 (IN_5)
DA_IN_6: IC2.5 (QF), IC3.6 (IN_6)
DA_IN_7: IC2.6 (QG), IC3.7 (IN_7)
DA_OUT_1: IC3.18 (OUT_1), R1.P$1 (1)
DA_OUT_2: IC3.17 (OUT_2), R2.P$1 (1)
DA_OUT_3: IC3.16 (OUT_3), R3.P$1 (1)
DA_OUT_4: IC3.15 (OUT_4), R4.P$1 (1)
DA_OUT_5: IC3.14 (OUT_5), R5.P$1 (1)
DA_OUT_6: IC3.13 (OUT_6), R6.P$1 (1)
DA_OUT_7: IC3.12 (OUT_7), R7.P$1 (1)
DEC_1: IC1.3 (Q0), T1.1 (G)
DEC_2: IC1.2 (Q1), T2.1 (G)
DEC_3: IC1.4 (Q2), T3.1 (G)
DEC_4: IC1.7 (Q3), T4.1 (G)
DEC_5: IC1.10 (Q4), T5.1 (G)
DEC_6: IC1.1 (Q5), T6.1 (G)
DEC_7: IC1.5 (Q6), T7.1 (G)
DEC_8: IC1.6 (Q7), T8.1 (G)
DEC_CLOCK: C1.7, IC1.14 (CLOCK)
DEC_RESET: C1.8, IC1.15 (RESET)
DIG_1: 7_SEG_1.4 (DIG_1), T1.2 (S)
DIG_2: 7_SEG_1.5 (DIG_2), T2.2 (S)
DIG_3: 7_SEG_2.4 (DIG_1), T3.2 (S)
DIG_4: 7_SEG_2.5 (DIG_2), T4.2 (S)
DIG_5: 7_SEG_3.4 (DIG_1), T5.2 (S)
DIG_6: 7_SEG_3.5 (DIG_2), T6.2 (S)
DIG_7: 7_SEG_4.4 (DIG_1), T7.2 (S)
DIG_8: 7_SEG_4.5 (DIG_2), T8.2 (S)
GND: C1.2, IC1.8 (GND), IC1.13 (!CLOCK_EN), IC2.8 (GND), IC3.9 (GND), R8.P$1 (1)
REG_CLOCK: C1.3, IC2.11 (CLOCK)
REG_DATA: C1.4, IC2.14 (DATA)
REG_ENABLE: C1.6, IC2.13 (!ENABLE), R8.P$2 (2)
REG_LATCH: C1.5, IC2.12 (LATCH)
SEG_A: 7_SEG_1.10 (SEG_A_2), 7_SEG_1.15 (SEG_A_1), 7_SEG_2.10 (SEG_A_2), 7_SEG_2.15 (SEG_A_1), 7_SEG_3.10 (SEG_A_2), 7_SEG_3.15 (SEG_A_1), 7_SEG_4.10 (SEG_A_2), 7_SEG_4.15 (SEG_A_1), R1.P$2 (2)
SEG_B: 7_SEG_1.12 (SEG_B_2), 7_SEG_1.13 (SEG_B_1), 7_SEG_2.12 (SEG_B_2), 7_SEG_2.13 (SEG_B_1), 7_SEG_3.12 (SEG_B_2), 7_SEG_3.13 (SEG_B_1), 7_SEG_4.12 (SEG_B_2), 7_SEG_4.13 (SEG_B_1), R2.P$2 (2)
SEG_C: 7_SEG_1.1 (SEG_C_1), 7_SEG_1.8 (SEG_C_2), 7_SEG_2.1 (SEG_C_1), 7_SEG_2.8 (SEG_C_2), 7_SEG_3.1 (SEG_C_1), 7_SEG_3.8 (SEG_C_2), 7_SEG_4.1 (SEG_C_1), 7_SEG_4.8 (SEG_C_2), R3.P$2 (2)
SEG_D: 7_SEG_1.3 (SEG_D_1), 7_SEG_1.6 (SEG_D_2), 7_SEG_2.3 (SEG_D_1), 7_SEG_2.6 (SEG_D_2), 7_SEG_3.3 (SEG_D_1), 7_SEG_3.6 (SEG_D_2), 7_SEG_4.3 (SEG_D_1), 7_SEG_4.6 (SEG_D_2), R4.P$2 (2)
SEG_E: 7_SEG_1.2 (SEG_E_1), 7_SEG_1.7 (SEG_E_2), 7_SEG_2.2 (SEG_E_1), 7_SEG_2.7 (SEG_E_2), 7_SEG_3.2 (SEG_E_1), 7_SEG_3.7 (SEG_E_2), 7_SEG_4.2 (SEG_E_1), 7_SEG_4.7 (SEG_E_2), R5.P$2 (2)
SEG_F: 7_SEG_1.11 (SEG_F_2), 7_SEG_1.14 (SEG_F_1), 7_SEG_2.11 (SEG_F_2), 7_SEG_2.14 (SEG_F_1), 7_SEG_3.11 (SEG_F_2), 7_SEG_3.14 (SEG_F_1), 7_SEG_4.11 (SEG_F_2), 7_SEG_4.14 (SEG_F_1), R6.P$2 (2)
SEG_G: 7_SEG_1.9 (SEG_G_2), 7_SEG_1.16 (SEG_G_1), 7_SEG_2.9 (SEG_G_2), 7_SEG_2.16 (SEG_G_1), 7_SEG_3.9 (SEG_G_2), 7_SEG_3.16 (SEG_G_1), 7_SEG_4.9 (SEG_G_2), 7_SEG_4.16 (SEG_G_1), R7.P$2 (2)
VCC: C1.1, IC1.16 (VCC), IC2.10 (!CLEAR), IC2.16 (VCC), T1.3 (D), T2.3 (D), T3.3 (D), T4.3 (D), T5.3 (D), T6.3 (D), T7.3 (D), T8.3 (D)

Board: 2 copper layers, 91.0 x 50.0 mm, 24 parts (0 on the bottom side), 45 nets.

## EAGLE design PixelBar/PixelBar-w6Pixels.brd

Parts:
IC1: 74LS595D; SO16
J1, J2: 22-27-2051-05; 6410-05
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18: LED5MM
R1, R2, R3, R4, R5, R6: RESISTOR-1/4W-SMD-1206; R1206
U$1, U$2, U$3, U$4, U$5, U$6: 2N7002-SOT23; SOT23

Connections:
CLOCK: IC1.11 (SCK), J1.3, J2.3
DATA: IC1.14 (SER), J1.5
DATA': IC1.9 (QH*), J2.5
GND: IC1.8 (GND), IC1.13 (G), J1.2, J2.2, R1.P$1 (1), R2.P$1 (1), R3.P$1 (1), R4.P$1 (1), R5.P$1 (1), R6.P$1 (1)
LATCH: IC1.12 (RCK), J1.4, J2.4
unnamed: LED1.K (C), LED2.A
unnamed: LED2.K (C), LED3.A
unnamed: LED4.K (C), LED5.A
unnamed: LED5.K (C), LED6.A
unnamed: LED3.K (C), R1.P$2 (2)
unnamed: LED6.K (C), R2.P$2 (2)
unnamed: LED9.K (C), R3.P$2 (2)
unnamed: LED12.K (C), R4.P$2 (2)
unnamed: LED8.K (C), LED9.A
unnamed: LED11.K (C), LED12.A
unnamed: LED15.K (C), R5.P$2 (2)
unnamed: LED18.K (C), R6.P$2 (2)
unnamed: LED14.K (C), LED15.A
unnamed: LED17.K (C), LED18.A
unnamed: LED16.K (C), LED17.A
unnamed: LED13.K (C), LED14.A
unnamed: LED10.K (C), LED11.A
unnamed: LED7.K (C), LED8.A
unnamed: LED1.A, U$1.3 (D)
unnamed: LED4.A, U$2.3 (D)
unnamed: LED7.A, U$3.3 (D)
unnamed: LED10.A, U$4.3 (D)
unnamed: LED13.A, U$5.3 (D)
unnamed: LED16.A, U$6.3 (D)
QA: IC1.15 (QA), U$1.1 (G)
QB: IC1.1 (QB), U$2.1 (G)
QC: IC1.2 (QC), U$3.1 (G)
QD: IC1.3 (QD), U$4.1 (G)
QE: IC1.4 (QE), U$5.1 (G)
QF: IC1.5 (QF), U$6.1 (G)
VCC: IC1.10 (SCL), IC1.16 (VCC), J1.1, J2.1, U$1.2 (S), U$2.2 (S), U$3.2 (S), U$4.2 (S), U$5.2 (S), U$6.2 (S)

Board: 2 copper layers, 33 parts (1 on the bottom side), 36 nets, no tracks yet.

## EAGLE design old-designs/SMD-Breakouts/eagle-files/g3528-plcc2-led-breakout.brd

Board: 2 copper layers, 15.2 x 6.3 mm, 3 parts (0 on the bottom side), 2 nets.

Parts:
C1, C2: BREAKAWAY_STRAIGHT_1_WIDE
L1: G3528

Connections:
unnamed: C1.1, L1.A
unnamed: C2.1, L1.C

## EAGLE design Pixel/Pixel.brd

Parts:
J1: 22-27-2021-02; 6410-02
LED1, LED2, LED3: LED_5MM
R1: RESISTOR-1/4W-SMD-1206; R1206

Connections:
+12V: J1.1, LED1.ANODE
GND: J1.2, R1.P$1 (1)
unnamed: LED1.CATHODE, LED2.ANODE
unnamed: LED2.CATHODE, LED3.ANODE
unnamed: LED3.CATHODE, R1.P$2 (2)

Board: 2 copper layers, 25.0 x 25.0 mm, 5 parts (1 on the bottom side), 5 nets.

## Commit log (part)

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2011-08-17 First checkin of completed design
2011-08-17 Added some basic READMEs
2012-01-03 Updated the README with info on the EAGLE library
2012-01-03 Added 2N7002 SMD MOSFET and 1/4W resistor with axial and SMD package. Cleaned up some of the other components with regard to labels, layers, etc.
2012-01-11 Added a very small PCB that carries 3 5mm LEDs to create a larger "pixel" from common high brightness LEDs instead of Power LEDs.
2012-01-11 Rearranged files for better overview.
2012-01-11 Added 3mm, 5mm and 10mm LEDs
2012-01-11 Updated the README for the Pixel
2012-02-23 Added SMD footprints for the HopeRF RFM01 and RFM02 modules. RFM01 is the ISM band FSK receiver, RFM02 is the ISM band FSK transmitter. Both modules are sold in Germany by Pollin.
2012-02-25 Added >NAME and >VALUE labels to the seven segment packages and symbols. Also added a drill hole for the potentiometer.
2012-03-08 Moved the seven-segment package pins onto a 0.1 inch grid for better signal routing. The MOSFET pin descriptions were switched onto another layer to make them appear by default in the schematics.
2012-03-08 Renamed the supply parts in some components to something useful.
2012-03-15 Added the DIP-18 package and created the symbol and device for the ULN2803 Darlington Array
2012-03-15 - Added the 74*595 shift register with two packages - Active low pins on ICs are now designated as such - Enabled user value on the resistor device - Added devices for 5-pin and 8-pin headers
2012-03-20 After the first (desastrously failed) attempt to layout the seven segment PCB, the second approach looks more promising so far.
2012-03-20 Added the backups of the PCB layout to the ignored files.
2012-03-20 Hmm, this was supposed to be the commit regarding the second try on layouting the PCB. So, here it goes: the is the first step of the second try of layouting the PCB and it looks more promising so fa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
2012-03-21 Assigned a proper name to a few more signals to make the layouting process easier (proper names enable precise filtering with the RATSNEST command)
2012-03-21 Started all over again, this time with a 2-layer PCB intended for professional manufacturing. Trying to squeeze SMD components and 'wire-intensive' parts like seven-segment displays on a single-sided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
2012-03-21 Fixed stupid bug in the circuit design: The digit anodes were all switched per seven-segment part, i.e. digit 1 was connected to the decade counter line 2 and digit 2 to decade counter line 1, and so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
2012-03-21 Finished the 2-layer PCB layout. Now all thats missing is a ground plane and some labeling.
2012-03-25 Duplicated some of the labels onto the bottom silkscreen layer. Especially the pin labeling is useful.
2012-04-07 Added PLCC6 package and RGB LED using this package
2012-04-09 Increased drill size on headers from .8mm to 1mm
    The drill size on the breakaway header packages was too small to actually
    fit any such header. D'oh! Increased the drill size to 1mm and adjusted
    the silkscreen markings accordingly.
2012-04-09 Created gerber files for project
    The design was translated to gerber files using the CAM job configuration
    from Seeed Studio for their Fusion PCB service. The job generated a lot
    more files, but Fusion PCB only needs those added now.
2012-04-09 New (correct) 8-pin connector and level fix for some labels.
    Replaced the 8-pin connector with the fixed version from the library (w/
    larger pads and 1mm drill size instead of .8mm). Had to rearrange some
    wires and labels. The bottom labels were accidentally placed on bPlace
    instead of bNames, this is now also fixed.
2012-04-09 Created a new library just for connectors.
    Since the content of a single library tends to get a little chaotic, I
    have decided t split the library by component group. This first new
    library contains all connectors specified so far. These have been moved
    from the general library to the new one.
2012-04-19 Added new packages for locking pin connectors, renamed the 90� packages.
    Specifications for locking headers taken from W�rth Elektronik datasheet
    for the WR-WTB 2.54mm header series
    (http://katalog.we-online.de/kataloge/eican/index.php?language=en&pf=619_0xx_110_21).
2012-04-20 Added a small selection of WIMA MKS-2 film capacitors.
2012-04-23 Fixed serious bug: the register's CLEAR pin is now pulled high instead of low.
    The CLEAR pin of the 74HC595 was accidentally connected to ground,
    pulling it low and thereby active all the time, preventing the register
    from working normally. It is now pulled to high and thereby inactive,
    allowing normal operation.
    The board now bears the version 1.1. The board has been updated to use the
    parts from the new sub-libraries. The last throughole resister has been
2012-05-06 Moved all LED components (inlcuding seven-segment) to a dedicated library file.
2012-05-06 Started work on a library for voltage regulators.
    So far not much to see except for the TO-220 package.
2012-05-16 Created a new library for integrated circuits and moved all IC devices and packages from the old main library to this new one
2012-05-17 Added MAX7219 IC, also added DIP-24 package, DIP-28 was created by mistake
2012-05-18 Added screw type terminal blocks with various pin counts
2012-05-18 Added electrolytic capacitor modelled after Yageo's S5 series, 35V, 10uF, 5x5mm can size
2012-05-19 Adjusted some small inconsistencies
2012-05-19 Created a breakout board for the MAX7219 chip.
    This board features a MAX7219 chip, stabilizing capacitors as suggested by
    the datasheet, voltage divider resistors for setting the maximum segment
    current and 4 reordered connectors, one for digits, one for segment, one
    control input and one control output to daisy chain multiple breaktout
    boards. The digit and segment connectors offer footprints for pin headers
    and screw type block terminals.
2012-05-22 Optimized the 2N7000 MOSFET component by rearranging some label, making the value user definable and adding a common prefix.
2012-05-22 Removed silkscreen overlap on SMD resistor
2012-05-26 Added pin headers with one and seven pins (mainly for breakouts)
2012-05-26 Added the WS2801 RGB controller IC and its SO-14 package
2012-05-26 Removed several stopmask/label overlaps
2012-06-03 Added two small SMD breakout board, one for SOP-14 SMD ICs, the other one for G3528 / PLCC2 SMD LEDs
2012-06-08 Added the SN75176B/MAX485 IC and associated DIP-8 package
2012-06-08 Added a USB Type B receptacle (USB 1.0/2.0 only)
2012-06-08 Added FTDIs FT232R USB/UART IC and the impossible SSOP28 package
2014-11-09 Added the LM358 op-amp
    And EAGLE did some reformatting...
2014-11-12 Added the HopeRF RFM69HCW transceiver
2014-11-12 Created a breakout board for the HopeRF RFM69HCW
2016-07-01 Updated submodules
2016-07-11 Added the Adafruit HUZZAH ESP8266 Basic Breakout
2016-07-11 Added 1S LiPo BMS/charger module
    The small modules found on ebay featuring a Micro-USB
    port, A TP4056 charge controller and a DW01 cell
    protection IC.
2016-07-21 Added new 10x13mm (5mm pitch) package for polarized caps
2016-07-21 Removed some unneccessary wires
2016-08-14 Updated the Sparkfun repository
2023-08-22 Wemos D1 Mainboard v1.0 added
    See README.md for more details on this design.
2023-08-22 Wemos D1 Mainboard: Added JLCPCB production files
    I generated the production files for the Wemos D1 Mainboard for
    production by JLCPCB. I sent those exact files off for production.
2023-08-22 Added folder for KiCad 3D models
    I initially added a 3D model for the TP4056 module, but it was
    not created by me, so I omitted it due to copyright reasons. It
    can be downloaded from:
    https://kicadrookie.blogspot.com/2022/01/tp4056-module-kicad-3d-asset.html
    If you choose to download it, the scaling factor for all three
    axes when importing into KiCad seems to be 0.393.
2023-08-24 Wemos D1 Mainboard: changed LEDs to 1210 footprint
    1210 is a bit more versatile and is actually the LED component
    size I have in stock.
    The board had to be rerouted, so there a lot of actual file
    changes.
2023-09-02 Kicad: Added footprint for 3528 / 1411 PLCC2 LED
    Kicad seems only to contain either footprints that are a little to
    small for 3528/1411 or are asymmetrical, where one pad is almost
    double in size compared to the other. My SMD LEDs don't reflect that,
    so I added my own footprint based on a Kingbright SMD LED datasheet.
2023-09-02 Kicad: Fixed TP4056 battery pin spacing
    The initial spacing between `OUT+` and `BAT+` and the corresponding
    negative pads was 2.54mm. This however, does not line up with any
    actual TP4056 module I own (Micro-USB and USB-C versions), the pins
    are spaced further apart. I updated the footprint to reflect that.
2023-09-02 Wemos D1 Mainboard: Generated JLCPCB production files for v1.2
2023-09-25 Added two seven-segment symbols
    - Kingbright DC52-11GWA (common cathode)
    - Oasistek TOD-4201FG-2 (common anode)
2023-09-25 Added several older dual seven segment displays (#8)
    * Added symbols/footprints for 4 older seven segment displays
    - Kingbright DA04/DC04 dual 10.2mm seven segment (common anode only)
    - Kingbright DC52/DA52 dual 13.2mm seven segment (common cathode only)
    - Oasistek TOD-4201FG-B dual 10.2mm seven segment (common anode)
    - RTF VQE 21 1.5x12.7mm seven segment (displays +1.8. when all segments
    are lit, and yes, this is the pre-1989 GDR part)
2023-09-28 VQE 21: Fixed silkscreen, added 2nd version with less silkscreen
    The components silkscreen extended over the edge of the carrier
    PCB in one of my projects and since KiCAD currently has no trimming
    feature, I created a version with less silkscreen.
    Normally I wouldn't bother, but with panelization, you'll get silkscreen
    spill from one board into the adjacent one.
2023-11-10 Added symbols for A2331 and MX612E components
    - A2331 is a current limiting load switch
    - MX612E is a controller IC for brushed DC motors
2023-11-10 Added symbols for A2331 and MX612E components (#10)
    - A2331 is a current limiting load switch
    - MX612E is a controller IC for brushed DC motors
2023-11-10 Reverse engineered schematic of a cheap watch winder PCB (#11)
    This is the schematic I reverse engineered from the control PCB
    of one of the cheap watch winders from Amazon/AliExpress where
    the PCB, DC socket and power switch form one combined part.
    There may be inaccuracies , especially regarding the microcontroller.
    The chosen PIC makes sense from a pinout and capabilities perspective,
    but it might be a different controller alltogether (markings had been
2024-04-21 Added Kicad 8 cache folder to .gitignore
2024-04-21 Added KiCads cache folder to ignore file (#12)
2024-10-21 Updated files to KiCad 8 (#13)
2024-10-21 Battery Discharger v1, initial commit
    Most battery dischargers are lacking the feature of approaching
    the low voltage threshold multiple times, each time reducing the
    discharge current, resulting in additional manual supervision
    needed or in batteries that are not accurately discharged.
    I will try to design my own (simple) discharger that incorporates
    this logic.
2024-10-21 Updated the README (#14)
2024-10-26 Added footprint for ALPS SKRK Series Push Button
    See https://tech.alpsalpine.com/e/products/category/tact-switch/sub/02/series/skrk/
    for more details regarding this component.

Notices in the files:
parts and their libraries:
icmi-passive-parts: ICMI Custom Parts for EAGLE by Hendrik Busch is licensed under a Creative Commons
Attribution-NonCommercial-ShareAlike 3.0 Germany License.
SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
